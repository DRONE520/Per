## servo/Kconfig
```kconfig
menuconfig EXAMPLES_SERVO
	bool "servo"
	default n
	---help---
		Enable support for servo
```
